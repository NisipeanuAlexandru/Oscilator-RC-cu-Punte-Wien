** Profile: "SCHEMATIC1-temperatura"  [ D:\aplicatii\P1_2024_431E_Nisipeanu_Alexandru_Cosmin_OW_N15_OrCAD\Schematics\nisipeanu_alexandru_p1_n15-pspicefiles\schematic1\temperatura.sim ]

** Creating circuit file "temperatura.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c8v2.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/irfr120npbf.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/mjd31cg.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/mjd32cg.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj177lt1g.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj309lt1g.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/1n4148.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bc807-25.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bc817-25.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bc846b.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bc856b.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c2v7.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v1.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v6.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v2.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v8.lib"
.LIB "c:/users/nisip/downloads/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c10.lib"
* From [PSPICE NETLIST] section of C:\Users\nisip\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice\17.2.0\PSpice.ini file:
.lib "nomd.lib"

*Analysis directives:
.TRAN  0 15m 0 1u
.TEMP -20 0 27 70 120
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
